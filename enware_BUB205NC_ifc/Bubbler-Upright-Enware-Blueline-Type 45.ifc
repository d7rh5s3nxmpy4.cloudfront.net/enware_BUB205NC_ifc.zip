Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-06-26T16:20:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 26 16:20:12 2019 * Host: A2K_QLD_L056 * Database: C:\Users\danh\AppData\Local\Temp\{9F9F50BC-A1CA-4B29-8094-DFE90FF44ADD}\ifc * Database version: 5507 * Database creation date: Wed Jun 26 16:20:12 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 26 16:20:12 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 26 16:20:12 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: -35, -18, -23, -549194; RefLongitude: 149, 7, 35, 603027; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Ground Floor
LongName: Ground Floor; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Level Head - Triangle (AUS): Type 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Ground Floor; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point

# IfcFlowTerminal: With Bottle Filler, Bubbler-Upright-Enware-Blueline-Type 45:With Bottle Filler:243219
In: Ground Floor
Material: Plastic_Enware_Blue, Metal_Enware_Steel_Stainless
Pset_ManufacturerTypeInformation - Manufacturer: Enware
Pset_DistributionFlowElementCommon - Reference: With Bottle Filler
Constraints - Level: Level: Ground Floor; Elevation: 300 mm; Host: Floor : Benchtop
Dimensions - Area: 0.0292137 m2; Volume: 0.000257272 m3
Identity Data - Mark: 14
Mechanical - System Classification: Domestic Cold Water
Other - Category: Plumbing Fixtures; Schedule Level: Level: Ground Floor; Family: Bubbler-Upright-Enware-Blueline-Type 45: With Bottle Filler; Family and Type: Bubbler-Upright-Enware-Blueline-Type 45: With Bottle Filler; Type: Bubbler-Upright-Enware-Blueline-Type 45: With Bottle Filler; Type Id: Bubbler-Upright-Enware-Blueline-Type 45: With Bottle Filler
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 1200 mm
Dimensions(Type) - Inlet Diameter: 12 mm
Identity Data(Type) - CreatedBy_ANZRS: Design Content; CreatedByURL_ANZRS: https://www.designcontent.com.au/; Description: The Enware Blueline bubbler and bottle filler range is a new design of drinking bubbler with many new and exclusive features making it practical for school drinking troughs and public spaces. It is available for Wall Mounting, Upright and Angled installation.; Manufacturer: Enware; Model: Blueline Type 45 Upright Bubbler; ModifiedIssue_ANZRS: 20190506; ProductCode_ANZRS: BUB205NCBF; Type Name: With Bottle Filler; URL: https://www.enware.com.au
Materials and Finishes(Type) - Bottle Filler Material: Plastic_Enware_Blue; Material_ANZRS: Metal_Enware_Steel_Stainless
Mechanical(Type) - CWFU: 0
Other(Type) - Category: Plumbing Fixtures; calcBottleFillerOffset: 36 mm; calcGuardOffset: 36.4 mm; calcHandleOffset: 32 mm; Family Name: Bubbler-Upright-Enware-Blueline-Type 45
Visibility(Type) - Bottle Filler: yes

# IfcFlowTerminal: Without Bottle Filler, Bubbler-Upright-Enware-Blueline-Type 45:Without Bottle Filler:243218
In: Ground Floor
Material: Plastic_Enware_Blue, Metal_Enware_Steel_Stainless
Pset_ManufacturerTypeInformation - Manufacturer: Enware
Pset_DistributionFlowElementCommon - Reference: Without Bottle Filler
Constraints - Elevation: 300 mm; Host: Floor : Benchtop; Level: Level: Ground Floor
Dimensions - Area: 0.0284904 m2; Volume: 0.000257328 m3
Identity Data - Mark: 13
Mechanical - System Classification: Domestic Cold Water
Other - Category: Plumbing Fixtures; Family: Bubbler-Upright-Enware-Blueline-Type 45: Without Bottle Filler; Family and Type: Bubbler-Upright-Enware-Blueline-Type 45: Without Bottle Filler; Schedule Level: Level: Ground Floor; Type: Bubbler-Upright-Enware-Blueline-Type 45: Without Bottle Filler; Type Id: Bubbler-Upright-Enware-Blueline-Type 45: Without Bottle Filler
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 1200 mm
Dimensions(Type) - Inlet Diameter: 12 mm
Identity Data(Type) - CreatedBy_ANZRS: Design Content; CreatedByURL_ANZRS: https://www.designcontent.com.au/; Description: The Enware Blueline bubbler and bottle filler range is a new design of drinking bubbler with many new and exclusive features making it practical for school drinking troughs and public spaces. It is available for Wall Mounting, Upright and Angled installation.; Manufacturer: Enware; Model: Blueline Type 45 Upright Bubbler; ModifiedIssue_ANZRS: 20190506; ProductCode_ANZRS: BUB205NC; Type Name: Without Bottle Filler; URL: https://www.enware.com.au
Materials and Finishes(Type) - Bottle Filler Material: Plastic_Enware_Blue; Material_ANZRS: Metal_Enware_Steel_Stainless
Mechanical(Type) - CWFU: 0
Other(Type) - Category: Plumbing Fixtures; calcBottleFillerOffset: 30 mm; calcGuardOffset: 29.5 mm; calcHandleOffset: 30 mm; Family Name: Bubbler-Upright-Enware-Blueline-Type 45
Visibility(Type) - Bottle Filler: no
